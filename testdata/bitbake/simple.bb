# Minimal recipe with no version in filename
SUMMARY = "Simple recipe"
LICENSE = "GPL-2.0-only"
